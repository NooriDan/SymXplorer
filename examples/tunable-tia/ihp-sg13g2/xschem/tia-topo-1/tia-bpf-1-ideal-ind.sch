** sch_path: examples/tunable-tia/ihp-sg13g2/xschem/tia-topo-1/tia-bpf-1-ideal-ind.sch
**.subckt tia-bpf-1-ideal-ind vdd vss inp inn von vop vbias
*.iopin vdd
*.iopin vss
*.ipin inp
*.ipin inn
*.opin von
*.opin vop
*.ipin vbias
XM1 vop vbias inn vss sg13_lv_nmos w={x_dut_nfet_w} l={x_dut_nfet_l} ng=1 m={x_dut_nfet_m} rfmode=1 mm_ok=1
XM2 von vbias inp vss sg13_lv_nmos w={x_dut_nfet_w} l={x_dut_nfet_l} ng=1 m={x_dut_nfet_m} rfmode=1 mm_ok=1
XC1 vdd von cap_cmim w={x_dut_cap_w} l={x_dut_cap_l} m={x_dut_cap_m} mm_ok=1
XC2 vdd vop cap_cmim w={x_dut_cap_w} l={x_dut_cap_l} m={x_dut_cap_m} mm_ok=1
XR1 inp vss sub! rppd w={x_dut_res_s_w} l={x_dut_res_s_l} m={x_dut_res_s_m} b=0 mm_ok=1
XR2 inn vss sub! rppd w={x_dut_res_s_w} l={x_dut_res_s_l} m={x_dut_res_s_m} b=0 mm_ok=1
XR3 von vop sub! rppd w={x_dut_res_3_w} l={x_dut_res_3_l} m={x_dut_res_3_m} b=0 mm_ok=1
L2 vdd von {x_dut_ind_size} m=1
L3 vdd vop @ind_size m=1
**.ends
.end
