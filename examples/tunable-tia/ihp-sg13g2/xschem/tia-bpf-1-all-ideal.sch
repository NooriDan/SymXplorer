** sch_path: examples/tunable-tia/ihp-sg13g2/xschem/tia-bpf-1-all-ideal.sch
**.subckt tia-bpf-1-all-ideal vdd vss inp inn von vop vbias
*.iopin vdd
*.iopin vss
*.ipin inp
*.ipin inn
*.opin von
*.opin vop
*.ipin vbias
XM1 vop vbias inn vss sg13_lv_nmos w=@nfet_w l=@nfet_l ng=1 m=@nfet_m rfmode=1 mm_ok=1
XM2 von vbias inp vss sg13_lv_nmos w=@nfet_w l=@nfet_l ng=1 m=@nfet_m rfmode=1 mm_ok=1
L2 vdd von @ind_size m=1
L3 vdd vop @ind_size m=1
C1 vdd von @cap_size m=1
C2 vdd vop @cap_size m=1
R1 inp vss @res_s_size m=1
R2 inn vss @res_s_size m=1
R3 vop von @res_z_size m=1
**.ends
.end
